v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {transmission_gate.sym} 340 -230 0 0 {name=x1}
