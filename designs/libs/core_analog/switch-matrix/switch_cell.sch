v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {transmission_gate.sym} 430 -420 0 0 {name=x1}
C {lab_wire.sym} 580 -450 0 1 {name=p1 lab=VDD}
C {lab_wire.sym} 580 -430 0 1 {name=p2 lab=VSS}
C {lab_wire.sym} 280 -330 0 0 {name=p3 lab=Q}
C {lab_wire.sym} 580 -410 0 1 {name=p4 lab=IN}
C {lab_wire.sym} 580 -390 0 1 {name=p5 lab=OUT}
C {lab_wire.sym} 580 -270 0 1 {name=p6 lab=VDD}
C {lab_wire.sym} 580 -250 0 1 {name=p7 lab=VSS}
C {lab_wire.sym} 280 -270 0 0 {name=p8 lab=D}
C {lab_wire.sym} 280 -250 0 0 {name=p9 lab=CLK}
C {lab_wire.sym} 580 -230 0 1 {name=p10 lab=Q}
C {iopin.sym} 120 -440 0 0 {name=p11 lab=VDD}
C {iopin.sym} 120 -420 0 0 {name=p17 lab=VSS}
C {ipin.sym} 120 -380 0 0 {name=p18 lab=CLK}
C {ipin.sym} 120 -400 0 0 {name=p19 lab=D}
C {iopin.sym} 120 -320 0 0 {name=p21 lab=IN}
C {iopin.sym} 120 -300 0 0 {name=p22 lab=OUT}
C {lab_wire.sym} 280 -350 0 0 {name=p13 lab=RSTN}
C {ipin.sym} 120 -360 0 0 {name=p15 lab=RSTN}
C {opin.sym} 120 -460 0 0 {name=p14 lab=Q}
C {dff.sym} 430 -250 0 0 {name=x2}
C {ipin.sym} 120 -340 0 0 {name=p12 lab=EN}
C {and2_1.sym} 430 -330 0 0 {name=x3}
C {lab_wire.sym} 580 -350 0 1 {name=p16 lab=VDD}
C {lab_wire.sym} 580 -330 0 1 {name=p20 lab=VSS}
C {lab_wire.sym} 280 -230 0 0 {name=p23 lab=EN}
C {lab_wire.sym} 580 -310 0 1 {name=p24 lab=SW
}
C {lab_wire.sym} 280 -450 0 0 {name=p25 lab=SW
}
