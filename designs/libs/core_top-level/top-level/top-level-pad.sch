v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {core_top-level/top-level/top-level.sym} 650 -80 0 0 {name=x1}
C {lab_wire.sym} 800 -120 0 1 {name=p1 lab=VDD}
C {lab_wire.sym} 800 -100 0 1 {name=p2 lab=VSS}
C {lab_wire.sym} 800 -80 0 1 {name=p3 lab=VDD}
C {lab_wire.sym} 800 -60 0 1 {name=p4 lab=VSS}
C {lab_wire.sym} 800 -40 0 1 {name=p5 lab=IO[15:0]}
C {lab_wire.sym} 500 -120 0 0 {name=p6 lab=RSTN}
C {lab_wire.sym} 500 -100 0 0 {name=p7 lab=CLK}
C {lab_wire.sym} 500 -80 0 0 {name=p8 lab=D}
C {lab_wire.sym} 1060 -260 0 1 {name=p23 lab=RSTN,CLK,D}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 300 -180 0 0 {name=IO2[15:0]
model=gf180mcu_fd_io__asig_5p0_extracted
spiceprefix=X
}
C {lab_wire.sym} 380 -180 0 1 {name=p9 lab=VSS}
C {lab_wire.sym} 380 -340 0 1 {name=p24 lab=VDD}
C {lab_wire.sym} 420 -180 0 1 {name=p25 lab=VSS}
C {lab_wire.sym} 420 -340 0 1 {name=p26 lab=VDD}
C {lab_wire.sym} 300 -260 0 0 {name=p27 lab=PAD_IO[15:0]}
C {lab_wire.sym} 500 -260 0 1 {name=p28 lab=IO[15:0]}
C {Chipathon2025_pads/xschem/symbols/io_in_s.sym} 800 -180 0 0 {name=IO1[2:0]
model=gf180mcu_fd_io__in_s
spiceprefix=X
}
C {lab_wire.sym} 880 -340 0 1 {name=p29 lab=VDD}
C {lab_wire.sym} 880 -180 0 1 {name=p30 lab=VSS}
C {lab_wire.sym} 800 -260 0 0 {name=p31 lab=PAD_RSTN,PAD_CLK,PAD_D}
C {lab_wire.sym} 1060 -220 0 1 {name=p32 lab=VSS}
C {lab_wire.sym} 1060 -240 0 1 {name=p33 lab=VSS}
C {lab_wire.sym} 920 -340 0 1 {name=p34 lab=VDD}
C {lab_wire.sym} 920 -180 0 1 {name=p35 lab=VSS}
C {ipin.sym} 80 -180 0 0 {name=p16 lab=VDD}
C {ipin.sym} 80 -160 0 0 {name=p17 lab=VSS}
C {ipin.sym} 80 -140 0 0 {name=p18 lab=PAD_RSTN}
C {ipin.sym} 80 -120 0 0 {name=p19 lab=PAD_CLK}
C {ipin.sym} 80 -100 0 0 {name=p20 lab=PAD_D}
C {iopin.sym} 80 -80 0 0 {name=p21 lab=PAD_IO[15:0]}
