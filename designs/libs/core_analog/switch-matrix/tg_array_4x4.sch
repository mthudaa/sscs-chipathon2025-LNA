v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {tg_array_4x1.sym} 470 -120 0 0 {name=x1}
C {tg_array_4x1.sym} 470 -240 0 0 {name=x2}
C {tg_array_4x1.sym} 470 -360 0 0 {name=x3}
C {tg_array_4x1.sym} 470 -480 0 0 {name=x4}
C {lab_wire.sym} 620 -150 0 1 {name=p1 lab=VDD}
C {lab_wire.sym} 620 -130 0 1 {name=p2 lab=VSS}
C {lab_wire.sym} 620 -110 0 1 {name=p3 lab=IN[3:0]}
C {lab_wire.sym} 620 -90 0 1 {name=p4 lab=OUT[3:0]}
C {lab_wire.sym} 320 -150 0 0 {name=p5 lab=SWR[3:0]}
C {lab_wire.sym} 320 -130 0 0 {name=p6 lab=SWC[3]}
C {lab_wire.sym} 320 -110 0 0 {name=p7 lab=CLK}
C {lab_wire.sym} 620 -270 0 1 {name=p8 lab=VDD}
C {lab_wire.sym} 620 -250 0 1 {name=p9 lab=VSS}
C {lab_wire.sym} 620 -230 0 1 {name=p10 lab=IN[3:0]}
C {lab_wire.sym} 620 -210 0 1 {name=p11 lab=OUT[3:0]}
C {lab_wire.sym} 320 -270 0 0 {name=p12 lab=SWR[3:0]}
C {lab_wire.sym} 320 -250 0 0 {name=p13 lab=SWC[2]}
C {lab_wire.sym} 320 -230 0 0 {name=p14 lab=CLK}
C {lab_wire.sym} 620 -390 0 1 {name=p15 lab=VDD}
C {lab_wire.sym} 620 -370 0 1 {name=p16 lab=VSS}
C {lab_wire.sym} 620 -350 0 1 {name=p17 lab=IN[3:0]}
C {lab_wire.sym} 620 -330 0 1 {name=p18 lab=OUT[3:0]}
C {lab_wire.sym} 320 -390 0 0 {name=p19 lab=SWR[3:0]}
C {lab_wire.sym} 320 -370 0 0 {name=p20 lab=SWC[1]}
C {lab_wire.sym} 320 -350 0 0 {name=p21 lab=CLK}
C {lab_wire.sym} 620 -510 0 1 {name=p22 lab=VDD}
C {lab_wire.sym} 620 -490 0 1 {name=p23 lab=VSS}
C {lab_wire.sym} 620 -470 0 1 {name=p24 lab=IN[3:0]}
C {lab_wire.sym} 620 -450 0 1 {name=p25 lab=OUT[3:0]}
C {lab_wire.sym} 320 -510 0 0 {name=p26 lab=SWR[3:0]}
C {lab_wire.sym} 320 -490 0 0 {name=p27 lab=SWC[0]}
C {lab_wire.sym} 320 -470 0 0 {name=p28 lab=CLK}
C {iopin.sym} 120 -360 0 0 {name=p29 lab=VDD}
C {iopin.sym} 120 -340 0 0 {name=p30 lab=VSS}
C {iopin.sym} 120 -320 0 0 {name=p31 lab=IN[3:0]}
C {iopin.sym} 120 -300 0 0 {name=p32 lab=OUT[3:0]}
C {ipin.sym} 120 -280 0 0 {name=p33 lab=SWR[3:0]}
C {ipin.sym} 120 -260 0 0 {name=p34 lab=SWC[3:0]}
C {ipin.sym} 120 -240 0 0 {name=p35 lab=CLK}
