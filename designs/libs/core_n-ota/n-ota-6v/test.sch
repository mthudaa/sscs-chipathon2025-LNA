v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {symbols/cap_mim_analog.sym} 100 -140 0 0 {name=C1
W=1e-6
L=1e-6
model=cap_mim_2f0_m3m4_noshield
spiceprefix=X
m=1}
